# Keil uVision project water_level_ctrl_04.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: water_level_ctrl_04 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s appl.c appl.h conf_appl.h conf_dev_chs.h conf_io.h conf_misc_ids.h conf_port.h constants.h dev_oper.c dev_oper.h gen_std_lib.h gen_std_lib_part_1.c gen_std_lib_part_2.c io_lib.c io_lib.h isr.c isr.h lcd.c lcd.h main.c main.h sw_lib.c sw_lib.h sys_status.h timer.c timer.h uart.c uart.h
